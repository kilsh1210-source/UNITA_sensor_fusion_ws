Commit message: bird

File: src/sensor_fusion_ws/unita_minicar_description/urdf/unita_minicar.urdf (robot description, URDF)
Before this commit: robot unita_minicar, 11 links, 10 joints
Joints:
- joint lidar_joint: origin xyz=0.500 0 0.119 rpy=0 0 0 -> xyz=0.500 0 0.119 rpy=0 0 3.141592653589793
